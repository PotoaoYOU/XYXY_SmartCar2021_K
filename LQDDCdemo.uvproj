# Keil uVision project LQDDCdemo.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LQdemo +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: readme.txt
  group app
    ./LQlib/app/: LQ_GPIO_KEY.c LQ_GPIO_KEY.h LQ_GPIO_LED.c LQ_GPIO_LED.h LQ_OLED096.c LQ_OLED096.h LQ_ICM20689.c LQ_ICM20689.h
  group driver
    ./LQlib/driver/: LQ_ADC.c LQ_ADC.h LQ_Encoder.c LQ_Encoder.h LQ_GPIO_EXIT.c LQ_GPIO_EXIT.h LQ_I2C.c LQ_I2C.h LQ_I2C_soft.c LQ_I2C_soft.h LQ_MotorServo.c LQ_MotorServo.h LQ_PWM.c LQ_PWM.h LQ_SPI.c LQ_SPI.h LQ_SPI_soft.c LQ_SPI_soft.h LQ_TIMER.c LQ_TIMER.h LQ_UART.c LQ_UART.h STC_DFP.LIB stc16f.h
  group user
    ./user/: include.h main.c
